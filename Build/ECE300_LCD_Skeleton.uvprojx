# Keil uVision project ECE300_LCD_Skeleton.uvprojx, settings and files
target Debug (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ECE300_LCD +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\Src\BSP;..\Src\BSP\MCU;..\Src\BSP\SPI;..\Src\App\LCD;..\Src\App\LED;..\Lib\Inc;..\Src\BSP\UART;..\Src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ../Src/: main.c GameObj.c GameObj.h GamePool.h GameSprites.h
  group App::LED
    ../Src/App/LED/: LED.h
  group App::GUI
    ../Src/App/LCD/: DPGUI_KEIL_CM4_V11.lib LCD_ST7735R.c fontarialbold16.c fontarialbold12.c fontarialbold24.c fontdigital720.c fontbradhitc16.c fontemoticons24.c fontcomic16.c
  group BSP
    ../Src/BSP/: BSP.c Hal.c IRQ.c Hal.h IRQ.h BSP.h retarget.c
    ../Src/BSP/UART/: UART.c
  group BSP::MCU
    ../Src/BSP/MCU/: startup_TM4C123.s system_TM4C123.c
  group BSP::SPI
    ../Src/BSP/SPI/: spim.c spim.h
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
